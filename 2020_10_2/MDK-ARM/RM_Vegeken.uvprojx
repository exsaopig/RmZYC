# Keil uVision project RM_Vegeken.uvprojx, settings and files
target RM_Vegeken (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rm2018 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --c99
  c include: ..\MDK-ARM;..\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\UserBsp\Inc;..\Information\Inc;..\AppCtrl\Inc;..\FreeRTOS\Source\CMSIS_RTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\MemMang;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\SysConfig
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_iwdg.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_iwdg.h
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: can.c dma.c gpio.c main.c rtc.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c tim.c usart.c iwdg.c
  group Application/UserBsp
    ../UserBsp/Src/: bsp_uart.c bsp_can.c bsp_flash.c bsp_imu.c bsp_io.c cpu_utils.c bsp_imu_9250.c
  group Application/Information
    ../UserBsp/Src/: bsp_oled.c
    ../Information/Src/: chassis_info.c gimbal_info.c shoot_info.c remote_info.c keyboard_info.c pc_info.c judgement_info.c imu_info.c calibrate_info.c
  group Application/AppCtrl
    ../AppCtrl/Src/: chassis_task.c gimbal_task.c shoot_task.c modeswitch_task.c info_get_task.c errordetect_task.c pid.c ramp.c comm_task.c oled_task.c TJU_imu_task.c UI_task.c
    ../Information/Src/: protocol.c
  group testfreertos
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Global
    ../SysConfig/: sys_config.h
  group SPRtos
    ../FreeRTOS/Source/include/: FreeRTOS.h FreeRTOSConfig.h
    ../Src/: freertos.c
  group Debug
    ../Src/: debug.c
    ../SysConfig/: debug.h
  group Doc/Readme
    ../: readme.txt task.txt
